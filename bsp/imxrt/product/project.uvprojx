# Keil uVision project project.uvprojx, settings and files
target rtthread (6230000::V6.23::ARMCLANG)
  device: MIMXRT1171CVM8A NXP
  pack: NXP.MIMXRT1171_DFP.25.06.00
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x20000000,0x040000) IROM(0x00200000,0x040000) XRAM(0x1ffe0000,0x020000) XRAM2(0x00000000,0x040000) XRAM3(0x20240000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1171CVM8A, __STDC_LIMIT_MACROS, ZAB_VENDOR_SILABS_NCP, __RTTHREAD__, XIP_BOOT_HEADER_DCD_ENABLE=1, ARM_MATH_CM7, SCHNEIDER_USE, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, NO_POPEN, SOC_IMXRT1170_SERIES, WITH_VENDOR_SILABS_OPTION, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, LFS_CONFIG=lfs_config.h, USE_RTTHREAD_RTOS, XIP_EXTERNAL_FLASH=1, RT_USING_ARM_LIBC
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: applications;..\..\..\components\net\at\include;..\..\..\components\net\at\at_socket;components\at_device-latest\inc;components\at_device-latest\class\esp32;components\CmBacktrace;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;components\cpu_usage-latest;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;board;board\MCUX_Config;board\ports;board\fal;..\libraries\drivers;..\..\..\components\fal\inc;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\legacy;..\..\..\components\legacy\dfs;..\libraries\MIMXRT1170\CMSIS\Include;..\libraries\MIMXRT1170\MIMXRT1171;..\libraries\MIMXRT1170\MIMXRT1171\drivers;..\libraries\MIMXRT1170\MIMXRT1171\periph;components\littlefs-v2.5.0;..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\components\net\lwip\port;..\..\..\components\libc\posix\delay;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\pthreads;..\..\..\components\net\netdev\include;..\..\..\components\net\sal\include;..\..\..\components\net\sal\include\socket;..\..\..\components\net\sal\impl;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\net\sal\include\socket\sys_socket;xip
  asm misc: -masm=auto
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x1ffe0000 size 0x20000
  memory RVCT7: RAM 0x0 size 0x40000
  memory RVCT8: RAM 0x20240000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.dcd_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Applications
    applications/: mnt.c main.c rs485_emc_test.c sysinit.c filesystem_emc_test.c eth_emc_test.c zigbee_emc_test.c
  group AT
    ../../../components/net/at/src/: at_client.c at_cli.c at_utils.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    components/at_device-latest/class/esp32/: at_device_esp32.c at_socket_esp32.c
    components/at_device-latest/src/: at_device.c
  group cm_backtrace
    components/CmBacktrace/: cmb_port.c cmb_flash_log.c cm_backtrace.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group cpu_usage
    components/cpu_usage-latest/: cpu_usage.c cpu_usage_cmd.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/phy/: phy.c
    ../../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c dcd.c
    ../libraries/drivers/: drv_eth.c drv_gpio.c drv_mdio.c drv_rtl8304.c drv_spi.c drv_uart.c
  group Fal
    ../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Legacy
    ../../../components/legacy/ipc/: workqueue_legacy.c
  group Libraries
    ../libraries/MIMXRT1170/MIMXRT1171/: system_MIMXRT1171.c
    ../libraries/MIMXRT1170/MIMXRT1171/arm/: startup_MIMXRT1171.s
    ../libraries/MIMXRT1170/MIMXRT1171/drivers/: fsl_dcdc.c fsl_gpio.c fsl_lpuart.c fsl_edma.c fsl_lpuart_edma.c fsl_pmu.c fsl_clock.c fsl_cache.c fsl_common_arm.c fsl_common.c fsl_enet.c fsl_lpspi.c fsl_anatop_ai.c
  group littlefs
    components/littlefs-v2.5.0/: lfs.c lfs_crc.c dfs_lfs.c lfs_util.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/lwiperf/: lwiperf.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group NetUtils
    components/iperf/: iperf.c
    components/telnet/: telnet.c
  group POSIX
    ../../../components/libc/posix/delay/: delay.c
    ../../../components/libc/posix/io/poll/: poll.c select.c
    ../../../components/libc/posix/pthreads/: pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_at.c af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group xip
    xip/: evkmimxrt1170_flexspi_nor_config.c fsl_flexspi_nor_boot.c
  group Zigbee
    zigbee/: zigbee.lib
