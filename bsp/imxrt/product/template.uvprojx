# Keil uVision project template.uvprojx, settings and files
target rtthread (6150000::V6.15::ARMCLANG)
  device: MIMXRT1171CVM8A NXP
  pack: NXP.MIMXRT1171_DFP.25.06.00
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x20000000,0x040000) IROM(0x00200000,0x040000) XRAM(0x1ffe0000,0x020000) XRAM2(0x00000000,0x040000) XRAM3(0x20240000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RELOC_VECTOR
  c misc: -xc -std=gnu99 -mimplicit-float
  asm misc: -masm=auto
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x1ffe0000 size 0x20000
  memory RVCT7: RAM 0x0 size 0x40000
  memory RVCT8: RAM 0x20240000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --legacyalign
